# Keil uVision project LPT100S2W.uvproj, settings and files
target LPT100S2W (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPT100S2W +hex
  AfterMake: fromelf.exe --bin --output ./output/LPT100S2W.bin ./output/LPT100S2W.axf
  AfterMake: LPB100_IMG_Tools.exe ./output/LPT100S2W.bin ./output/LPT100S2W_UPGARDE.bin
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __KEIL_MDK__ __LPT100__
  c misc: --diag_suppress=494  --c99
  c include: ../sdk/1.51/include/
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group src
    ../src/: startup.c app_main.c
  group libs
    ../sdk/1.51/libs/: LPB100Kernel.lib
