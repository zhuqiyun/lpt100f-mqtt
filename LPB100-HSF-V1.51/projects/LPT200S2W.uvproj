# Keil uVision project LPT200S2W.uvproj, settings and files
target LPT200S2W (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPT200S2W +hex
  AfterMake: fromelf.exe --bin --output ./output/LPT200S2W.bin ./output/LPT200S2W.axf
  AfterMake: LPB100_IMG_Tools.exe ./output/LPT200S2W.bin ./output/LPT200S2W_UPGARDE.bin
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __KEIL_MDK__ __LPT200__
  c misc: --diag_suppress=494  --c99
  c include: ../sdk/1.51/include/
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group src
    ../src/: startup.c app_main.c
  group libs
    ../sdk/1.51/libs/: LPB100Kernel8B.lib
